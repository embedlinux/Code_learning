# Keil uVision project rtos_demo.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: ARMCM7 ARM
  pack: ARM.CMSIS.5.0.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M7") CLOCK(12000000) ESEL ELITTLE
  output: rtos_demo
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\freertos\include;..\freertos\portable\RVDS\ARM_CM7;..\User
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group User
    ../User/: main.c
  group Freertos/Ports
    ../freertos/portable/RVDS/ARM_CM7/: port.c
  group Freertos/Source
    ../freertos/: list.c task.c
    ../freertos/include/: list.h FreeRTOSConfig.h portmacro.h FreeRTOS.h portable.h task.h projdefs.h
  group Doc
    ../Doc/: readme.txt
software components: CMSIS:CORE 5.0.1, Device:Startup 1.0.1
