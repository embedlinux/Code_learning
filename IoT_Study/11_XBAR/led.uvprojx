# Keil uVision project led.uvprojx, settings and files
target led_debug (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MIMXRT1064DVL6A NXP
  pack: NXP.MIMXRT1064_DFP.10.0.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: led +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CPU_MIMXRT1064DVL6A
  c misc: --library_interface=armcc --library_type=standardlib --diag_suppress=66,1296,186
  c include: .\FSLLIB;.\CORE;.\cmsis
  asm define: __STARTUP_INITIALIZE_NONCACHEDATA
  scatter file: .\scatter\MIMXRT1064xxxxx_ram_0x1400.scf
  link misc: --remove
  group source
    ./source/: main.c
  group core
    ./CORE/: delay.c delay.h key.c led.c led.h key.h uart.c uart.h exit.c exit.h wdog.c wdog.h timer.c timer.h
  group cmsis
    ./cmsis/: cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cm7.h mpu_armv7.h
target led_flexspi (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MIMXRT1064DVL6A NXP
  pack: NXP.MIMXRT1064_DFP.10.0.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: led.out +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1,NDEBUG, CPU_MIMXRT1064DVL6A
  c misc: as above
  c include: .\FSLLIB;.\CORE;.\cmsis
  asm define: NDEBUG,__STARTUP_INITIALIZE_NONCACHEDATA
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: .\scatter\MIMXRT1064xxxxx_flexspi_nor.scf
  link misc: --remove 
--keep=*(.boot_hdr.ivt) 
--keep=*(.boot_hdr.boot_data) 
--keep=*(.boot_hdr.conf) 
--predefine="-DXIP_BOOT_HEADER_ENABLE=1"
software components: CMSIS:CORE 5.1.2, Board Support:SDK Project Template:project_template 1.0.0, Device:SDK Drivers:clock 2.1.0, Device:SDK Drivers:common 2.0.0, Device:SDK Drivers:gpio 2.0.1, Device:SDK Drivers:gpt 2.0.0, Device:SDK Drivers:iomuxc 2.0.0, Device:SDK Drivers:lpuart 2.2.5, Device:SDK Drivers:pit 2.0.1, Device:SDK Drivers:qtmr 2.0.0, Device:SDK Drivers:rtwdog 2.0.0, Device:SDK Drivers:wdog 2.0.1, Device:SDK Drivers:xbara 2.0.3, Device:SDK Drivers:xip 2.0.0, Device:SDK Utilities:debug_console 1.0.0, Device:Startup 1.0.0
