# IAR project led_blinky.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1064xxx6A NXP MIMXRT1064xxx6A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: DEBUG; CPU_MIMXRT1064DVL6A
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe167
  ICCARM.CCIncludePath2: ../../..; ..
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkOutputFile: led_blinky.out
  ILINK.IlinkIcfFile: MIMXRT1064xxxxx_ram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration flexspi_nor_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; CPU_MIMXRT1064DVL6A
  ICCARM.CCOptLevel: 2
  ILINK.IlinkIcfFile: MIMXRT1064xxxxx_flexspi_nor.icf
configuration sdram_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: SKIP_SYSCLK_INIT; DEBUG; CPU_MIMXRT1064DVL6A
  ICCARM.CCOptLevel: 2
  ILINK.IlinkIcfFile: MIMXRT1064xxxxx_sdram.icf
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MIMXRT1064DVL6A
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
configuration flexspi_nor_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; NDEBUG; CPU_MIMXRT1064DVL6A
  ICCARM.CCOptLevel: 2
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkIcfFile: MIMXRT1064xxxxx_flexspi_nor.icf
configuration sdram_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; SKIP_SYSCLK_INIT; CPU_MIMXRT1064DVL6A
  ICCARM.CCOptLevel: 2
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkIcfFile: MIMXRT1064xxxxx_sdram.icf
  group source
    ../: led_blinky.c
  group doc
    ../: readme.txt
  group CMSIS-Pack/Board Support SDK Project Template
    RTE/EVK-MIMXRT1064_BSP/NXP/: clock_config.h clock_config.c board.h pin_mux.h board.c pin_mux.c
