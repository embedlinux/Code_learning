# IAR project dev_composite_hid_audio_unified_bm.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT685_M33 NXP MIMXRT685_M33
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 58
  General.FPU2: 6
  ICCARM.CCDefines: _DEBUG=1; DEBUG; CPU_MIMXRT685SEVKA=1; BOOT_HEADER_ENABLE=1; ARM_MATH_CM33; USB_STACK_BM; USB_STACK_USE_DEDICATED_RAM=1; SDK_I2C_BASED_COMPONENT_USED=1; BOARD_USE_CODEC=1
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ../../../../../../CMSIS/Include; ../../../../../../devices; ../../../../../../devices/MIMXRT685S; ../../../../../../platform/drivers; ../../../../../../platform/drivers/common; ../../../..; ../../../../../../middleware/usb; ../../../../../../middleware/usb/osa; ../../../../../../middleware/usb/include; ../../../../../../middleware/usb/device; ../../../../../../middleware/usb/device; ../../../../../../middleware/usb/include; ../../../../../../middleware/usb/osa; ../../../../../../middleware/usb/phy; ../../../../../../devices/MIMXRT685S/drivers; ../../../../../../devices/MIMXRT685S/drivers; ../../../../../../devices/MIMXRT685S/drivers; ../../../../../../devices/MIMXRT685S/drivers; ../../../../../../devices/MIMXRT685S/drivers; ../../../../../../components/codec/wm8904; ../../../../../../components/codec; ../../../../../../devices/MIMXRT685S/drivers; ../../../../../../devices/MIMXRT685S/drivers; ../../../../../../devices/MIMXRT685S/drivers; ../../../../../../devices/MIMXRT685S/drivers; ../../../../../../devices/MIMXRT685S/drivers; ../../../../../../devices/MIMXRT685S/drivers; ../../../../../../devices/MIMXRT685S/xip; ../../../../../../devices/MIMXRT685S; ../../../../../../devices/MIMXRT685S/utilities/str; ../../../../../../devices/MIMXRT685S/utilities/debug_console; ../../../../../../components/uart; ../../../../../../devices/MIMXRT685S/drivers; ../../../../../../components/serial_manager; ../../../../../../components/serial_manager; ../../../../../../components/lists; ../../../../../../devices/MIMXRT685S/drivers; ../../../../../../devices/MIMXRT685S/drivers; ../../../../../../devices/MIMXRT685S/drivers; ../../../../../../devices/MIMXRT685S/drivers; ../../../../../../devices/MIMXRT685S/drivers
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  OBJCOPY.OOCOutputFile: sdk20-app.bin
  ILINK.IlinkOutputFile: dev_composite_hid_audio_unified_bm.out
  ILINK.IlinkConfigDefines: __stack_size__=0x1000
  ILINK.IlinkIcfFile: MIMXRT685Sxxxx_ram.icf
  ILINK.IlinkAdditionalLibs: ../../../../../../devices/MIMXRT685S/iar/iar_lib_power.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration flash_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; BOOT_HEADER_ENABLE=1; CPU_MIMXRT685SEVKA=1; ARM_MATH_CM33; USB_STACK_BM; USB_STACK_USE_DEDICATED_RAM=1; SDK_I2C_BASED_COMPONENT_USED=1; BOARD_USE_CODEC=1
  ICCARM.CCOptLevel: 1
  ILINK.IlinkIcfFile: MIMXRT685Sxxxx_flash.icf
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: _DEBUG=0; NDEBUG; CPU_MIMXRT685SEVKA=1; BOOT_HEADER_ENABLE=1; ARM_MATH_CM33; USB_STACK_BM; USB_STACK_USE_DEDICATED_RAM=1; SDK_I2C_BASED_COMPONENT_USED=1; BOARD_USE_CODEC=1
  ICCARM.IExtraOptions: --no_unaligned_access
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG
configuration flash_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; CPU_MIMXRT685SEVKA=1; BOOT_HEADER_ENABLE=1; NDEBUG; ARM_MATH_CM33; USB_STACK_BM; USB_STACK_USE_DEDICATED_RAM=1; SDK_I2C_BASED_COMPONENT_USED=1; BOARD_USE_CODEC=1
  ICCARM.CCOptLevel: 3
  ILINK.IlinkIcfFile: MIMXRT685Sxxxx_flash.icf
  group doc
    ../: readme.txt
  group source
    ../: audio_unified.c audio_unified.h composite.c composite.h hid_keyboard.c hid_keyboard.h usb_device_descriptor.c usb_device_descriptor.h usb_device_config.h
  group board
    ../: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
  group usb/device/source
    ../../../../../../middleware/usb/device/: usb_device_dci.c usb_device_dci.h
    ../: usb_device_ch9.c usb_device_ch9.h
  group usb/device/source/lpcip3511
    ../../../../../../middleware/usb/device/: usb_device_lpcip3511.c usb_device_lpcip3511.h
  group usb/device/include
    ../../../../../../middleware/usb/device/: usb_device.h
  group usb/device/class
    ../: usb_device_class.c usb_device_class.h
  group usb/device/class/audio
    ../: usb_device_audio.c usb_device_audio.h
  group usb/device/class/hid
    ../: usb_device_hid.c usb_device_hid.h
  group usb/include
    ../../../../../../middleware/usb/include/: usb.h usb_misc.h usb_spec.h
  group usb/phy
    ../../../../../../middleware/usb/phy/: usb_phy.c usb_phy.h
  group osa
    ../../../../../../middleware/usb/osa/: usb_osa.h usb_osa_bm.h usb_osa_bm.c
  group drivers
    ../../../../../../devices/MIMXRT685S/drivers/: fsl_i2c.h fsl_i2c.c fsl_i2s.h fsl_i2s.c fsl_i2s_dma.h fsl_i2s_dma.c fsl_dma.c fsl_dma.h fsl_usart.h fsl_usart.c fsl_i3c.h fsl_i3c.c fsl_pint.h fsl_pint.c fsl_inputmux.h fsl_inputmux.c fsl_sctimer.h fsl_sctimer.c fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_power.h fsl_power.c fsl_flexcomm.h fsl_flexcomm.c fsl_iopctl.h fsl_gpio.h fsl_gpio.c fsl_reset.h fsl_reset.c fsl_inputmux_connections.h
  group codec
    ../../../../../../components/codec/wm8904/: fsl_wm8904.h fsl_wm8904.c
    ../../../../../../components/codec/: fsl_codec_common.h fsl_codec_common.c
  group xip
    ../../../../../../devices/MIMXRT685S/xip/: flash_config.c flash_config.h
  group device
    ../../../../../../devices/MIMXRT685S/: fsl_device_registers.h MIMXRT685S.h MIMXRT685S_features.h system_MIMXRT685S.c system_MIMXRT685S.h
  group utilities
    ../../../../../../devices/MIMXRT685S/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../devices/MIMXRT685S/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../../devices/MIMXRT685S/utilities/: fsl_assert.c
  group component/uart
    ../../../../../../components/uart/: uart.h usart_adapter.c
  group component/serial_manager
    ../../../../../../components/serial_manager/: serial_manager.h serial_manager.c serial_port_uart.h serial_port_uart.c
  group component/lists
    ../../../../../../components/lists/: generic_list.h generic_list.c
  group startup
    ../../../../../../devices/MIMXRT685S/iar/: startup_MIMXRT685S.s
  group CMSIS
    ../../../../../../CMSIS/Include/: core_cm33.h tz_context.h cmsis_armcc.h cmsis_armclang.h cmsis_gcc.h cmsis_compiler.h cmsis_version.h mpu_armv7.h core_armv8mbl.h core_armv8mml.h arm_common_tables.h arm_const_structs.h arm_math.h cmsis_iccarm.h mpu_armv8.h
