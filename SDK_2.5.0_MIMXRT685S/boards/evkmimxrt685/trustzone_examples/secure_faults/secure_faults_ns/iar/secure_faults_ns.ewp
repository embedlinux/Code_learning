# IAR project secure_faults_ns.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT685_M33 NXP MIMXRT685_M33
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 58
  General.FPU2: 6
  ICCARM.CCDefines: DEBUG; CPU_MIMXRT685SEVKA; BOOT_HEADER_ENABLE=1; ARM_MATH_CM33
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ../../secure_faults_s; ../../../..; ../../../../../../CMSIS/Include; ../../../../../../devices; ../../../../../../devices/MIMXRT685S/drivers; ../../../../../../devices/MIMXRT685S/drivers; ../../../../../../devices/MIMXRT685S/drivers; ../../../../../../devices/MIMXRT685S/xip; ../../../../../../devices/MIMXRT685S; ../../../../../../devices/MIMXRT685S/utilities/str; ../../../../../../devices/MIMXRT685S/utilities/debug_console; ../../../../../../components/uart; ../../../../../../components/serial_manager; ../../../../../../components/serial_manager; ../../../../../../devices/MIMXRT685S/drivers; ../../../../../../components/lists; ../../../../../../devices/MIMXRT685S/drivers; ../../../../../../devices/MIMXRT685S/drivers; ../../../../../../devices/MIMXRT685S/drivers; ../../../../../../devices/MIMXRT685S/drivers
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  OBJCOPY.OOCOutputFile: sdk20-app.bin
  ILINK.IlinkOutputFile: secure_faults_ns.out
  ILINK.IlinkIcfFile: MIMXRT685Sxxxx_ram_ns.icf
  ILINK.IlinkAdditionalLibs: ../../../../../../devices/MIMXRT685S/iar/iar_lib_power.a; ../../secure_faults_s/iar/debug/secure_faults_s_import_lib.o
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration flash_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; BOOT_HEADER_ENABLE=1; CPU_MIMXRT685SEVKA; ARM_MATH_CM33
  ICCARM.CCOptLevel: 1
  ILINK.IlinkIcfFile: MIMXRT685Sxxxx_flash_ns.icf
  ILINK.IlinkAdditionalLibs: ../../../../../../devices/MIMXRT685S/iar/iar_lib_power.a; ../../secure_faults_s/iar/flash_debug/secure_faults_s_import_lib.o
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MIMXRT685SEVKA; BOOT_HEADER_ENABLE=1; ARM_MATH_CM33
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG
  ILINK.IlinkAdditionalLibs: ../../../../../../devices/MIMXRT685S/iar/iar_lib_power.a; ../../secure_faults_s/iar/release/secure_faults_s_import_lib.o
configuration flash_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; CPU_MIMXRT685SEVKA; BOOT_HEADER_ENABLE=1; NDEBUG; ARM_MATH_CM33
  ICCARM.CCOptLevel: 3
  ILINK.IlinkIcfFile: MIMXRT685Sxxxx_flash_ns.icf
  ILINK.IlinkAdditionalLibs: ../../../../../../devices/MIMXRT685S/iar/iar_lib_power.a; ../../secure_faults_s/iar/flash_release/secure_faults_s_import_lib.o
  group source
    ../: secure_faults_ns.c
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group trustzone
    ../../secure_faults_s/: veneer_table.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../../devices/MIMXRT685S/drivers/: fsl_common.h fsl_common.c fsl_clock.h fsl_clock.c fsl_power.h fsl_power.c fsl_usart.h fsl_usart.c fsl_flexcomm.h fsl_flexcomm.c fsl_iopctl.h fsl_gpio.h fsl_gpio.c fsl_reset.h fsl_reset.c
  group xip
    ../../../../../../devices/MIMXRT685S/xip/: flash_config.c flash_config.h
  group device
    ../../../../../../devices/MIMXRT685S/: fsl_device_registers.h MIMXRT685S.h MIMXRT685S_features.h system_MIMXRT685S.c system_MIMXRT685S.h
  group utilities
    ../../../../../../devices/MIMXRT685S/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../devices/MIMXRT685S/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../../devices/MIMXRT685S/utilities/: fsl_assert.c
  group component/uart
    ../../../../../../components/uart/: uart.h usart_adapter.c
  group component/serial_manager
    ../../../../../../components/serial_manager/: serial_manager.h serial_manager.c serial_port_uart.h serial_port_uart.c
  group component/lists
    ../../../../../../components/lists/: generic_list.h generic_list.c
  group startup
    ../../../../../../devices/MIMXRT685S/iar/: startup_MIMXRT685S.s
  group CMSIS
    ../../../../../../CMSIS/Include/: core_cm33.h tz_context.h cmsis_armcc.h cmsis_armclang.h cmsis_gcc.h cmsis_compiler.h cmsis_version.h mpu_armv7.h core_armv8mbl.h core_armv8mml.h arm_common_tables.h arm_const_structs.h arm_math.h cmsis_iccarm.h mpu_armv8.h
