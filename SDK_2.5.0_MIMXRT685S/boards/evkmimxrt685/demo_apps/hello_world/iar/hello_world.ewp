# IAR project hello_world.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 59
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG; CPU_MIMXRT685SEVKA; BOOT_HEADER_ENABLE=1; ARM_MATH_CM33
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ../../..; ../../../../../CMSIS/Include; ../../../../../devices; ../../../../../devices/MIMXRT685S/drivers; ../../../../../devices/MIMXRT685S/xip; ../../../../../devices/MIMXRT685S; ../../../../../devices/MIMXRT685S/utilities/str; ../../../../../devices/MIMXRT685S/utilities/debug_console; ../../../../../components/uart; ../../../../../components/serial_manager; ../../../../../devices/MIMXRT685S/drivers; ../../../../../components/lists; ../../../../../devices/MIMXRT685S/drivers
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  OBJCOPY.OOCOutputFile: puf_test.bin
  ILINK.IlinkOutputFile: hello_world.out
  ILINK.IlinkIcfFile: MIMXRT685Sxxxx_ram.icf
  ILINK.IlinkAdditionalLibs: ../../../../../devices/MIMXRT685S/iar/iar_lib_power.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration flash_debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MIMXRT685_M33 NXP MIMXRT685_M33
  General.CoreVariant: 58
  General.FPU2: 6
  ICCARM.CCDefines: DEBUG; FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; BOOT_HEADER_ENABLE=1; CPU_MIMXRT685SEVKA; ARM_MATH_CM33
  ICCARM.CCIncludePath2: ..; ../../..; ../../../../../CMSIS/Include; ../../../../../devices; ../../../../../devices/MIMXRT685S/drivers; ../../../../../devices/MIMXRT685S/drivers; ../../../../../devices/MIMXRT685S/drivers; ../../../../../devices/MIMXRT685S/xip; ../../../../../devices/MIMXRT685S; ../../../../../devices/MIMXRT685S/utilities/str; ../../../../../devices/MIMXRT685S/utilities/debug_console; ../../../../../components/uart; ../../../../../components/serial_manager; ../../../../../components/serial_manager; ../../../../../devices/MIMXRT685S/drivers; ../../../../../components/lists; ../../../../../devices/MIMXRT685S/drivers; ../../../../../devices/MIMXRT685S/drivers; ../../../../../devices/MIMXRT685S/drivers; ../../../../../devices/MIMXRT685S/drivers
  ICCARM.CCOptLevel: 1
  OBJCOPY.OOCOutputFile: sdk20-app.bin
  ILINK.IlinkIcfFile: MIMXRT685Sxxxx_flash.icf
configuration release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MIMXRT685_M33 NXP MIMXRT685_M33
  General.CoreVariant: 58
  General.FPU2: 6
  ICCARM.CCDefines: NDEBUG; CPU_MIMXRT685SEVKA; BOOT_HEADER_ENABLE=1; ARM_MATH_CM33
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG
  OBJCOPY.OOCOutputFile: sdk20-app.bin
  ILINK.IlinkIcfFile: MIMXRT685Sxxxx_ram.icf
configuration flash_release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MIMXRT685_M33 NXP MIMXRT685_M33
  General.CoreVariant: 58
  General.FPU2: 6
  ICCARM.CCDefines: FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; CPU_MIMXRT685SEVKA; BOOT_HEADER_ENABLE=1; NDEBUG; ARM_MATH_CM33
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: sdk20-app.bin
  ILINK.IlinkIcfFile: MIMXRT685Sxxxx_flash.icf
  group board
    ../: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
  group CMSIS
    ../../../../../CMSIS/Include/: arm_common_tables.h arm_const_structs.h arm_math.h cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv8mbl.h core_armv8mml.h core_cm33.h mpu_armv7.h mpu_armv8.h tz_context.h
  group component/lists
    ../../../../../components/lists/: generic_list.c generic_list.h
  group component/serial_manager
    ../../../../../components/serial_manager/: serial_manager.c serial_manager.h serial_port_uart.c serial_port_uart.h
  group component/uart
    ../../../../../components/uart/: uart.h usart_adapter.c
  group device
    ../../../../../devices/MIMXRT685S/: fsl_device_registers.h MIMXRT685S.h MIMXRT685S_features.h system_MIMXRT685S.c system_MIMXRT685S.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/MIMXRT685S/drivers/: fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_flexcomm.c fsl_flexcomm.h fsl_gpio.c fsl_gpio.h fsl_iopctl.h fsl_power.c fsl_power.h fsl_puf.c fsl_puf.h fsl_reset.c fsl_reset.h fsl_usart.c fsl_usart.h
  group source
    ../: hello_world.c
  group startup
    ../../../../../devices/MIMXRT685S/iar/: startup_MIMXRT685S.s
  group utilities
    ../../../../../devices/MIMXRT685S/utilities/: fsl_assert.c
    ../../../../../devices/MIMXRT685S/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../devices/MIMXRT685S/utilities/str/: fsl_str.c fsl_str.h
  group xip
    ../../../../../devices/MIMXRT685S/xip/: flash_config.c flash_config.h
